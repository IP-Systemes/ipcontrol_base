#Add fstab and custom prompt
FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"
