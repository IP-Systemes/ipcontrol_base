FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI = "file://ipsec-tools-${PV}.tar.bz2 \
           file://0001-Fix-warning-with-gcc-4.8.patch \
